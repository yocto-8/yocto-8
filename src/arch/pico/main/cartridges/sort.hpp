#include <string_view>

static constexpr std::string_view cartridge = R"(pico-8 cartridge // http://www.pico-8.com
version 23
__lua__
-- sorting demo
-- by zep

-- starting giraffee heights
g = {3,5,7,2,9,1,2}

-- draw a giraffe at x,y with
-- neck length of l
function draw_giraffe(x,y,l)

	-- body
	spr(33,x-8,y-8,2,1)
	
	-- neck for l segments
	for i=1,l do
		spr(18, x,y-8-i*8)
	end
	
	-- put head on top
	spr(2, x,y-16-l*8)

end

function _draw()
	cls(12)
	rectfill(0,110,127,127,14)
	
	--print("press 🅾️ to randomize",
	--      22, 2, 7)
	--print("press ❎ to sort",
	--      32, 10, 7)
	
	for i=1,7 do
		draw_giraffe(i*16,110,g[i])
	end

end

function _update()
	
	-- ❎ to sort
	
	--if (btnp(5)) then
	if (btn(5)) then
		
		-- look for a pair of
		-- giraffees out of order
		
		for i=1,6 do
			
			if (g[i] > g[i+1]) then
				
				-- the left one is taller,
				-- so swap them!
				temp   = g[i]
				g[i]   = g[i+1]
				g[i+1] = temp
				
				--sfx(0)
				
				-- just one swap for now!
				break 
				
			end
		end
		
	end
	
	
	-- 🅾️ to randomize
	
	-- if (btnp(4)) then
	if (btn(4)) then
		
		for i=1,7 do
			g[i]=flr(rnd(9))
		end
		
		--sfx(1)
		
	end


end
__gfx__
00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
00700700000000000900900000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
00077000000000000a00a00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
00077000000000000aaaaa0000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
00700700000000000aa1aaaa00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
00000000000000000aaaaaaa00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
000000000000000000aaa00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
000000000000000000aaa00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
000000000000000000a9900000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
000000000000000000a9900000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
000000000000000000aa900000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
000000000000000000aaa00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
0000000000000000009aa00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
0000000000000000009aa00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
000000000000000000aaa00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
00000000000000000aa9900000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
00000000000aaa999aa9900000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
0000000006aaaa99aaaaa00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
000000006099aaaaaaaaa00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
000000000099aaaaa99aa00000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
00000000009040000900400000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
0000000000a040000a00400000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
0000000000a040000a00400000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
__label__
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccc777c777c777cc77cc77cccccc77777cccccc777cc77ccccc777c777c77cc77ccc77c777c777c777c777ccccccccccccccccccccccc
cccccccccccccccccccccc7c7c7c7c7ccc7ccc7ccccccc77ccc77cccccc7cc7c7ccccc7c7c7c7c7c7c7c7c7c7c777cc7cccc7c7ccccccccccccccccccccccccc
cccccccccccccccccccccc777c77cc77cc777c777ccccc77c7c77cccccc7cc7c7ccccc77cc777c7c7c7c7c7c7c7c7cc7ccc7cc77cccccccccccccccccccccccc
cccccccccccccccccccccc7ccc7c7c7ccccc7ccc7ccccc77ccc77cccccc7cc7c7ccccc7c7c7c7c7c7c7c7c7c7c7c7cc7cc7ccc7ccccccccccccccccccccccccc
cccccccccccccccccccccc7ccc7c7c777c77cc77ccccccc77777ccccccc7cc77cccccc7c7c7c7c7c7c777c77cc7c7c777c777c777ccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccc777c777c777cc77cc77cccccc77777cccccc777cc77cccccc77cc77c777c777ccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccc7c7c7c7c7ccc7ccc7ccccccc77c7c77cccccc7cc7c7ccccc7ccc7c7c7c7cc7cccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccc777c77cc77cc777c777ccccc777c777cccccc7cc7c7ccccc777c7c7c77ccc7cccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccc7ccc7c7c7ccccc7ccc7ccccc77c7c77cccccc7cc7c7ccccccc7c7c7c7c7cc7cccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccc7ccc7c7c777c77cc77ccccccc77777ccccccc7cc77cccccc77cc77cc7c7cc7cccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc9cc9ccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccaccaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccaaaaacccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccaa1aaaacccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccaaaaaaacccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccaa9ccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccc9cc9ccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccaccacccccccccccccccccccccccccccccaa9ccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccaaaaaccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccaa1aaaacccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccaaaaaaacccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccaa9cccccccccccccccccccccccccccccaa9ccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccccccccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccc9cc9ccccccccccccca99ccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccaccacccccccccccccaa9cccccccccccccccccccccccccccccaa9ccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccaaaaaccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccaa1aaaacccccccccc9aaccccccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccaaaaaaacccccccccc9aaccccccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccaaacccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccaaacccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccca99ccccccccccccca99ccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccca99ccccccccccccca99ccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccaa9cccccccccccccaa9cccccccccccccccccccccccccccccaa9ccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccaaacccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccc9aaccccccccccccc9aaccccccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccc9aaccccccccccccc9aaccccccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccaaacccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccccccccccccccccccaaacccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccccccccccccccccccca99ccccccccccccca99ccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccc9cc9ccccccccccccca99ccccccccccccca99ccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccaccacccccccccccccaa9cccccccccccccaa9cccccccccccccccccccccccccccccaa9ccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccaaaaaccccccccccccaaacccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccaa1aaaacccccccccc9aaccccccccccccc9aaccccccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccaaaaaaacccccccccc9aaccccccccccccc9aaccccccccccccccccccccccccccccc9aaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
ccccccccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccccccccccccccccccca99ccccccccccccccccccccccccccccccccccccccccccc
cccccccccccccccccca99ccccccccccccca99ccccccccccccca99cccccccccccc9cc9ccccccccccccca99cccccccccccccccccccccccccccc9cc9ccccccccccc
ccccccccccccccccccaa9cccccccccccccaa9cccccccccccccaa9ccccccccccccaccacccccccccccccaa9ccccccccccccccccccccccccccccaccaccccccccccc
ccccccccccccccccccaaacccccccccccccaaacccccccccccccaaaccccccccccccaaaaaccccccccccccaaaccccccccccccccccccccccccccccaaaaacccccccccc
cccccccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccaa1aaaacccccccccc9aaccccccccccccccccccccccccccccaa1aaaacccccccc
cccccccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccaaaaaaacccccccccc9aaccccccccccccccccccccccccccccaaaaaaacccccccc
ccccccccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccc
ccccccccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccccccccccccccccccaaaccccccccccc
cccccccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccccccccccccccccccca99ccccccccccc
cccccccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccca99cccccccccccc9cc9ccccccccccccca99ccccccccccc
ccccccccccccccccccaa9cccccccccccccaa9cccccccccccccaa9cccccccccccccaa9cccccccccccccaa9ccccccccccccaccacccccccccccccaa9ccccccccccc
ccccccccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaaccccccccccccaaaaaccccccccccccaaaccccccccccc
cccccccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccaa1aaaacccccccccc9aaccccccccccc
cccccccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccaaaaaaacccccccccc9aaccccccccccc
ccccccccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaaccccccccccc
ccccccccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaaccccccccccc
cccccccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccc
cccccccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccccca99ccccccccccc
ccccccccccccccccccaa9cccccccccccccaa9cccccccccccccaa9cccccccccccccaa9cccccccccccccaa9cccccccccccccaa9cccccccccccccaa9ccccccccccc
ccccccccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaaccccccccccc
cccccccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccc
cccccccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccccc9aaccccccccccc
ccccccccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaacccccccccccccaaaccccccccccc
cccccccccccccccccaa99ccccccccccccaa99ccccccccccccaa99ccccccccccccaa99ccccccccccccaa99ccccccccccccaa99ccccccccccccaa99ccccccccccc
cccccccccccaaa999aa99ccccccaaa999aa99ccccccaaa999aa99ccccccaaa999aa99ccccccaaa999aa99ccccccaaa999aa99ccccccaaa999aa99ccccccccccc
ccccccccc6aaaa99aaaaacccc6aaaa99aaaaacccc6aaaa99aaaaacccc6aaaa99aaaaacccc6aaaa99aaaaacccc6aaaa99aaaaacccc6aaaa99aaaaaccccccccccc
cccccccc6c99aaaaaaaaaccc6c99aaaaaaaaaccc6c99aaaaaaaaaccc6c99aaaaaaaaaccc6c99aaaaaaaaaccc6c99aaaaaaaaaccc6c99aaaaaaaaaccccccccccc
cccccccccc99aaaaa99aaccccc99aaaaa99aaccccc99aaaaa99aaccccc99aaaaa99aaccccc99aaaaa99aaccccc99aaaaa99aaccccc99aaaaa99aaccccccccccc
cccccccccc9c4cccc9cc4ccccc9c4cccc9cc4ccccc9c4cccc9cc4ccccc9c4cccc9cc4ccccc9c4cccc9cc4ccccc9c4cccc9cc4ccccc9c4cccc9cc4ccccccccccc
ccccccccccac4ccccacc4cccccac4ccccacc4cccccac4ccccacc4cccccac4ccccacc4cccccac4ccccacc4cccccac4ccccacc4cccccac4ccccacc4ccccccccccc
ccccccccccac4ccccacc4cccccac4ccccacc4cccccac4ccccacc4cccccac4ccccacc4cccccac4ccccacc4cccccac4ccccacc4cccccac4ccccacc4ccccccccccc
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee

__sfx__
0001000022050280502f0500000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000
000200001b5501d5501b5501b5501b540165301d5301d520005000050000500005000050000500005000050000500005000050000500005000050000500005000050000500005000050000500005000050000500
)";